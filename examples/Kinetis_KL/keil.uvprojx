# Keil uVision project keil.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MKL03Z16xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.6.0
  cpu: IROM(0x00000000,0x4000) IRAM(0x1FFFFE00,0x0800) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: keil
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x1ffffe00 size 0x800
software components: CMSIS:CORE 4.1.0, Device:Startup 1.0.0

# Keil uVision project _f1_keil.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: armpit
  c flags: Optim=3 uC99=1 wLevel=2
  c define: TIMER_INTERRUPTS_OFF
  c include: ..\..\..\lib;..\..\..\lib\stm32f10x\lib;..\..\..\lib\util;..\..\..\lib\stm32_common;..\..\..\lib\mcortex_core\armv7m;..\..\..\lib\util\RF22;..\..\..\lib\mcortex_core
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ../src/: main.cpp
  group lib
    ../../../lib/stm32f10x/lib/: dma.cpp dma.h dma_cpp.h flash.c flash.h gpio.cpp gpio.h gpio_cpp.h i2c.cpp i2c.h i2c_cpp.h rcc.c rcc.h system_init.c usart.cpp usart.h usart_cpp.h irq.h GPIO_Helper.cpp GPIO_Helper.h RCC_Helper.c RCC_Helper.h afio.c adc.h adc_cpp.h afio.h bkp.h pwr.h rtc.h rtc_cpp.h adc.cpp bkp.cpp pwr.cpp rtc.cpp
    ../../../lib/: common.h stm32.h
    ../../../lib/stm32_common/: peripheral.cpp peripheral.h spi.cpp spi.h spi_cpp.h timer.cpp timer.h timer_cpp.h exti.cpp exti.h system_time.c
    ../../../lib/stm32f10x/startup/arm/: startup_stm32f10x_md.s
  group core
    ../../../lib/mcortex_core/armv7m/: nvic.c nvic.h system_control.c system_control.h
    ../../../lib/mcortex_core/: systick.c systick.h
  group util
    ../../../lib/util/RF22/: si4432.cpp

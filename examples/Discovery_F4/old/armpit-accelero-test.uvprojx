# Keil uVision project armpit-accelero-test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: armpit
  c flags: Optim=1 uC99=1 wLevel=2
  c define: USE_SPI USE_TIMER
  c include: ..\..\..\lib;.
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group lib
    ../../../lib/: _components.h common.h exti.cpp exti.h gpio.cpp gpio.h gpio_cpp.h i2c.cpp i2c.h i2c_cpp.h system_init.c timer.cpp timer.h timer_cpp.h startup_stm32f407xx.s peripheral.cpp spi.cpp flash.c
    ../../../lib/core/: nvic.c nvic.h system_control.c system_control.h systick.c systick.h
    ../../../lib/rcc/: rcc.c
  group src
    ./: lis3dsh.cpp main.cpp

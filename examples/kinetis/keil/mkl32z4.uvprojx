# Keil uVision project mkl32z4.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: MKL34Z64VLH4 NXP
  pack: NXP.MKL34Z4_DFP.10.0.3
  cpu: IRAM(0x1ffff800,0x2000) IROM(0x00000000,0x010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: mkl32z4
  c flags: Optim=2 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x1ffff800 size 0x2000
  scatter file: .\MKL34Z64xxx4_flash.scf
  group Source Group 1
    ./: startup_MKL34Z4.s
    ../src/: common.h debug.c debug.h gpio.c gpio.h irq_MKL34Z4.h main.c mcg.c mcg.h nvic.c nvic.h port.h sim.c sim.h system_control.c system_control.h system_time.c system_time.h systick.c systick.h

# Keil uVision project _f411_keil.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F411RCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: armpit-adc-singleconversion
  c flags: Optim=1 uC99=1 wLevel=2
  c include: ..\..\..\lib;..\..\..\lib\stm32f4xx\lib;..\..\..\lib\stm32_common;..\..\..\lib\mcortex_core\armv7m;..\..\..\lib\util\displays;..\src;..\..\..\lib\mcortex_core
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group src
    ./: main.cpp
    ../../../lib/stm32f4xx/startup/ARM/: startup_stm32f411xe.s
    ../../../lib/util/displays/5110_2/: lcd5110.cpp lcd5110.h
  group lib
    ../../../lib/stm32f4xx/lib/: flash.c rcc.c RCC_Helper.c system_init.c adc.cpp dma.cpp gpio.cpp i2c.cpp syscfg.cpp GPIO_Helper.cpp usart.cpp
    ../../../lib/stm32_common/: dac.cpp dac.h dac_cpp.h exti.cpp exti.h exti_cpp.h new.h peripheral.cpp peripheral.h spi.h spi_cpp.h timer.h timer.cpp spi.cpp
    ../../../lib/mcortex_core/: systick.c systick.h
    ../../../lib/mcortex_core/armv7m/: debug.c debug.h nvic.c nvic.h system_control.c system_control.h

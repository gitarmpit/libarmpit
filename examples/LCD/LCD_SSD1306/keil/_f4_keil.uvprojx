# Keil uVision project _f4_keil.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: armpit-adc-singleconversion
  c flags: Optim=1 uC99=1 wLevel=2
  c define: USE_DAC USE_DMA
  c include: ..\..\..\lib;..\..\..\lib\stm32f4xx\lib;..\..\..\lib\stm32_common;..\..\..\lib\mcortex_core\armv7m;..\..\..\lib\util\displays;..\src
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group src
    ../../../lib/stm32f4xx/startup/ARM/: startup_stm32f407xx.s
    ./: main.cpp
    ../../../lib/util/displays/: Adafruit_GFX.cpp Adafruit_GFX.h
    ../../../lib/util/displays/SSD1306/: Adafruit_SSD1306.cpp Adafruit_SSD1306.h
  group lib
    ../../../lib/stm32f4xx/lib/: flash.c rcc.c RCC_Helper.c system_init.c adc.cpp dma.cpp gpio.cpp i2c.cpp syscfg.cpp GPIO_Helper.cpp usart.cpp
    ../../../lib/stm32_common/: dac.cpp dac.h dac_cpp.h exti.cpp exti.h exti_cpp.h new.h peripheral.cpp peripheral.h spi.h spi_cpp.h timer.h timer.cpp spi.cpp
    ../../../lib/mcortex_core/: systick.c systick.h
    ../../../lib/mcortex_core/armv7m/: debug.c debug.h nvic.c nvic.h system_control.c system_control.h

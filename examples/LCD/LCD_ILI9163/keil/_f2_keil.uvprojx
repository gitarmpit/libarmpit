# Keil uVision project _f2_keil.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F207VCTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: armpit-adc-singleconversion
  c flags: Optim=1 uC99=1 wLevel=2
  c define: USE_DAC USE_DMA
  c include: ..\..\..\lib;..\..\..\lib\stm32f2xx\lib;..\..\..\lib\stm32_common;..\..\..\lib\mcortex_core\armv7m;..\..\..\lib\util\displays
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group src
    ./: main.cpp
    ../../../lib/stm32f2xx/startup/arm/: startup_stm32f207xx.s
    ../../../lib/util/displays/9163/: TFT_ILI9163C.cpp TFT_ILI9163C.h TFT_ILI9163C_registers.h TFT_ILI9163C_settings.h
    ../../../lib/util/displays/: Adafruit_GFX.cpp
  group lib
    ../../../lib/stm32f2xx/lib/: flash.c rcc.c RCC_Helper.c system_init.c dma.cpp gpio.cpp syscfg.cpp GPIO_Helper.cpp i2c.cpp usart.cpp
    ../../../lib/stm32_common/: dac.h dac_cpp.h exti.cpp exti.h exti_cpp.h new.h peripheral.cpp peripheral.h spi.cpp spi.h spi_cpp.h timer.h
    ../../../lib/mcortex_core/: systick.c systick.h
    ../../../lib/mcortex_core/armv7m/: debug.c debug.h nvic.c nvic.h system_control.c system_control.h

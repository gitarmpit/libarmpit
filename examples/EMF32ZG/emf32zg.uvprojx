# Keil uVision project emf32zg.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: EFM32HG108F32 Silicon Labs
  pack: Keil.EFM32HGxxx_DFP.1.1.0
  cpu: IROM(0x00000000,0x00008000) IRAM(0x20000000,0x00001000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: emf32zg +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: ..\..\lib\EFM32ZG\lib;..\..\lib;..\..\lib\util
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group src
    ./: main.c
  group lib
    ../../lib/EFM32ZG/lib/: cmu.c emu.c gpio.c msc.c acmp.h adc.h cmu.h dma.h emu.h gpio.h i2c.h leuart0.h msc.h prs.h rmu.h rtc.h timer0.h timer1.h usart1.h vcmp.h
    ../../lib/EFM32ZG/lib/core/: nvic.c nvic.h system_control.c system_control.h systick.c systick.h
    ../../lib/EFM32ZG/startup/: startup_efm32zg.s

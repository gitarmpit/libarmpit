# Keil uVision project keil-f4.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: armpit
  c flags: Optim=1 uC99=1 wLevel=2
  c define: USE_TIMER
  c include: ..\..\..\lib;..\..\..\lib\stm32f4xx\lib;..\..\..\lib\util;..\..\..\lib\common_st_cortex
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group src
    ./: main.cpp
  group lib
    ../../../lib/util/: GPIO_Helper.cpp GPIO_Helper.h RCC_Helper.c RCC_Helper.h IRremote.cpp IRRemote.h
    ../../../lib/common_st_cortex/: peripheral.cpp peripheral.h spi.cpp spi.h spi_cpp.h timer.cpp timer.h timer_cpp.h
    ../../../lib/stm32f4xx/lib/: dma.cpp dma.h dma_cpp.h exti.cpp exti.h flash.c flash.h gpio.cpp gpio.h gpio_cpp.h i2c.cpp i2c.h i2c_cpp.h new.h rcc.c rcc.h rcc_ahb.h rcc_apb1.h rcc_apb2.h rcc_bdcr.h rcc_cfgr.h rcc_ckgatenr.h rcc_cr.h rcc_csr.h rcc_pllcfgr.h system_init.c usart.cpp usart.h usart_cpp.h
    ../../../lib/stm32f4xx/lib/core/: irq.h irq_f401xx.h irq_f405xx.h irq_f407xx.h irq_f411xx.h irq_f415xx.h irq_f417xx.h irq_f427xx.h irq_f429xx.h irq_f437xx.h irq_f439xx.h irq_f446xx.h nvic.c nvic.h system_control.c system_control.h systick.c systick.h
    ../../../lib/stm32f4xx/startup/ARM/: startup_stm32f407xx.s

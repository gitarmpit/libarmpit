# Keil uVision project _f4_keil.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F401RCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: armpit
  c flags: Optim=1 uC99=1 wLevel=2
  c define: USE_TIMER
  c include: ..\..\..\lib;..\..\..\lib\stm32f4xx\lib;..\..\..\lib\util;..\..\..\lib\stm32_common;..\..\..\lib\mcortex_core\armv7m
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group src
    ../src/: main.cpp
  group lib
    ../../../lib/stm32f4xx/lib/: adc.cpp adc.h adc_cpp.h dma.cpp dma.h dma_cpp.h flash.c flash.h gpio.cpp gpio.h gpio_cpp.h GPIO_Helper.cpp GPIO_Helper.h i2c.cpp i2c.h i2c_c.c i2c_cpp.h irq.h irq_f401xx.h irq_f405xx.h irq_f407xx.h irq_f411xx.h irq_f415xx.h irq_f417xx.h irq_f427xx.h irq_f429xx.h irq_f437xx.h irq_f439xx.h irq_f446xx.h new.h rcc.c rcc.h rcc_ahb.h rcc_apb1.h rcc_apb2.h rcc_bdcr.h rcc_cfgr.h rcc_ckgatenr.h rcc_cr.h rcc_csr.h RCC_Helper.c RCC_Helper.h rcc_pllcfgr.h system_init.c usart.cpp usart.h usart_cpp.h
    ../../../lib/stm32f4xx/startup/ARM/: startup_stm32f401xc.s
    ../../../lib/stm32_common/: exti.cpp peripheral.cpp spi.cpp timer.cpp
  group core
    ../../../lib/mcortex_core/: systick.c
    ../../../lib/mcortex_core/armv7m/: nvic.c nvic.h system_control.c system_control.h

# Keil uVision project _f4_keil.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: armpit-adc-singleconversion
  c flags: Optim=2 uC99=1 wLevel=2
  c include: ..\..\..\lib;..\..\..\lib\stm32f4xx\lib;..\..\..\lib\util;..\..\..\lib\stm32_common;..\..\..\lib\mcortex_core\armv7m;..\..\..\lib\mcortex_core
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group lib
    ../../../lib/stm32_common/: peripheral.cpp timer.cpp system_time.c
    ../../../lib/mcortex_core/: systick.c
    ../../../lib/mcortex_core/armv7m/: nvic.c system_control.c
    ../../../lib/stm32f4xx/lib/: rcc.c system_init.c gpio.cpp
    ../../../lib/stm32f4xx/startup/ARM/: startup_stm32f4xx.s
  group src
    ../src/: main.cpp
  group util
    ../../../lib/util/button_handler/: button.cpp button_handler.cpp

# Keil uVision project _f4_keil.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: armpit-adc-singleconversion
  c flags: Optim=1 uC99=1 wLevel=2
  c define: USE_ADC TIMER_INTERRUPTS_OFF
  c include: ..\..\..\lib;..\..\..\lib\stm32f4xx\lib;..\..\..\lib\util;..\..\..\lib\stm32_common;..\..\..\lib\mcortex_core\armv7m;..\..\..\lib\mcortex_core;..\eclipse\src
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group lib
    ../../../lib/stm32_common/: dac.cpp exti.cpp peripheral.cpp spi.cpp timer.cpp system_time.c
    ../../../lib/mcortex_core/: systick.c
    ../../../lib/mcortex_core/armv7m/: debug.c nvic.c system_control.c
    ../../../lib/stm32f4xx/lib/: dma_c.c flash.c i2c_c.c pwr.c rcc.c RCC_Helper.cpp rtc.c system_init.c adc.cpp dma.cpp gpio.cpp GPIO_Helper.cpp i2c.cpp syscfg.cpp usart.cpp
    ../../../lib/stm32f4xx/startup/ARM/: startup_stm32f4xx.s
  group common
    ../eclipse/src/common/: colorconversion.cpp filter.cpp maths.cpp
  group config
    ../eclipse/src/config/: feature.cpp profile.cpp
  group drivers
    ../eclipse/src/drivers/: accgyro_mpu.cpp accgyro_mpu6500.cpp adc.cpp barometer_bmp280.cpp buf_writer.cpp bus_i2c_stm32f10x.cpp compass_ak8963.cpp compass_hmc5883l.cpp gyro_sync.cpp pwm_mapping.cpp pwm_output.cpp pwm_rx.cpp sonar_hcsr04.cpp sound_beeper.cpp
  group fc
    ../eclipse/src/fc/: boot.cpp cleanflight_fc.cpp config.cpp fc_tasks.cpp rate_profile.cpp rc_adjustments.cpp rc_controls.cpp rc_curves.cpp runtime_config.cpp
  group flight
    ../eclipse/src/flight/: altitudehold.cpp failsafe.cpp gps_conversion.cpp imu.cpp mixer.cpp navigation.cpp pid.cpp pid_luxfloat.cpp pid_mw23.cpp pid_mwrewrite.cpp
  group io
    ../eclipse/src/io/: beeper.cpp display.cpp gps.cpp motor_and_servo.cpp statusindicator.cpp
  group rx
    ../eclipse/src/rx/: pwm.cpp rx.cpp
  group scheduler
    ../eclipse/src/scheduler/: scheduler.cpp
  group sensors
    ../eclipse/src/sensors/: acceleration.cpp barometer.cpp battery.cpp boardalignment.cpp compass.cpp gyro.cpp initialisation.cpp sensors.cpp sonar.cpp

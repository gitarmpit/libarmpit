# Keil uVision project _f1_keil_3.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: armpit
  c flags: Optim=1 uC99=1 wLevel=2
  c misc: --dollar
  c include: ..\..\..\lib;;..\..\..\lib\stm32f10x;..\..\..\lib\stm32f10x\arm
  asm include: ..\..\..\lib\stm32f10x\arm
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group lib
    ../../../lib/stm32f10x/arm/: debug.s flash.s gpio.s gpio_regs.s init.s irq.s macros.s nvic.s rcc.s rcc_regs.s scb.s scb_regs.s stm32.s systick.s timer.s timer_regs.s udiv64.s
    ../../../lib/stm32f10x/arm/startup/: startup_stm32f10x.s
  group inc
    ../../../lib/stm32f10x/: flash.h gpio.h irq.h nvic.h rcc.h debug.h scb.h systick.h timer.h
  group src3
    ./src3/: capture_cfg.s data.s handler.s imp.s main.s pwm_out.s
